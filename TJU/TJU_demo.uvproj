# Keil uVision project TJU_demo.uvproj, settings and files
target tju_demo (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: TJU_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\TJU
  group source
    ./: STARTUP.A51 main.c
